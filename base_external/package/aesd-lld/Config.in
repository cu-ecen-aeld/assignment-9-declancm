## base_external/package/aesd-lld/Config.in
```kconfig
config BR2_PACKAGE_AESD_LLD
	bool "aesd-lld"
	help
        Includes misc-modules and scull modules.
```
